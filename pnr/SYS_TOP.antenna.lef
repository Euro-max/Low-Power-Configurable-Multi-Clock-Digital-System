

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO SYS_TOP 
  PIN SI[4] 
  END SI[4]
  PIN SI[3] 
    ANTENNAPARTIALMETALAREA 1.799 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.65319 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 5.247 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.4305 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 5.247 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.4305 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 13.47 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 64.9831 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 470.406 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 2276.44 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.06379 LAYER VIA56 ;
  END SI[3]
  PIN SI[2] 
    ANTENNAPARTIALMETALAREA 1.954 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.39874 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 7.862 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 38.0086 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 3.197 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.57 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 13.224 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 63.7998 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 12.067 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 58.2347 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 244.853 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 1195.14 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 4.06379 LAYER VIA67 ;
  END SI[2]
  PIN SI[1] 
    ANTENNAPARTIALMETALAREA 1.399 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.72919 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.632 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.23232 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 17.1979 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 89.2902 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.3546 LAYER VIA34 ;
  END SI[1]
  PIN SI[0] 
    ANTENNAPARTIALMETALAREA 3.071 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.7715 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.505 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.62145 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 9.579 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 46.2674 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 316.831 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 1534.82 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA45 ;
  END SI[0]
  PIN SO[4] 
  END SO[4]
  PIN SO[3] 
    ANTENNADIFFAREA 0.401 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.535 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3858 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.401 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.401 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNADIFFAREA 0.401 LAYER METAL6 ; 
    ANTENNAPARTIALMETALAREA 7.4188 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 34.8725 LAYER METAL6 ;
    ANTENNAPARTIALCUTAREA 0.2592 LAYER VIA67 ;
    ANTENNADIFFAREA 0.401 LAYER METAL7 ; 
    ANTENNAPARTIALMETALAREA 46.512 LAYER METAL7 ;
    ANTENNAPARTIALMETALSIDEAREA 273.031 LAYER METAL7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL7 ; 
    ANTENNAMAXAREACAR 804.217 LAYER METAL7 ;
    ANTENNAMAXSIDEAREACAR 4568.34 LAYER METAL7 ;
  END SO[3]
  PIN SO[2] 
    ANTENNAPARTIALMETALAREA 11.75 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.5175 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.6 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 0.66 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.367 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 55.4088 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 272.433 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.57123 LAYER VIA45 ;
  END SO[2]
  PIN SO[1] 
    ANTENNADIFFAREA 0.524 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.443 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.7508 LAYER METAL3 ;
  END SO[1]
  PIN SO[0] 
    ANTENNAPARTIALMETALAREA 21.602 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 103.906 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.524 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 1.557 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.68157 LAYER METAL4 ;
  END SO[0]
  PIN REF_CLK 
    ANTENNAPARTIALMETALAREA 0.537 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.58297 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 3.748 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.2203 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.288 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.38768 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 0.761917 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 3.81057 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END REF_CLK
  PIN UART_CLK 
    ANTENNAPARTIALMETALAREA 0.241 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.15921 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.616 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.96536 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 2.494 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3809 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 1.95886 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 9.63069 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END UART_CLK
  PIN scan_clk 
    ANTENNAPARTIALMETALAREA 0.255 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.22655 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 3.584 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.4314 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 1.30521 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 6.36099 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END scan_clk
  PIN scan_rst 
    ANTENNAPARTIALMETALAREA 1.699 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.17219 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.407 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.96007 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 2.864 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.9682 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1274 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 39.5094 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 192.477 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.70016 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 6.418 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 31.063 LAYER METAL5 ;
    ANTENNAGATEAREA 0.7644 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 47.9055 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 233.114 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.70016 LAYER VIA56 ;
  END scan_rst
  PIN SE 
    ANTENNAPARTIALMETALAREA 4.487 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 21.5825 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4069 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 13.1643 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 62.7626 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 0.489453 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 15.045 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 74.2904 LAYER METAL3 ;
    ANTENNAGATEAREA 3.5126 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 20.8547 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 98.3191 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.26861 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 3.056 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.8918 LAYER METAL4 ;
    ANTENNAGATEAREA 3.6283 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 21.6969 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 102.423 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.26861 LAYER VIA45 ;
  END SE
  PIN test_mode 
    ANTENNAPARTIALMETALAREA 1.617 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.77777 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.26 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 7.85808 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 36.0605 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.277692 LAYER VIA23 ;
  END test_mode
  PIN RST 
    ANTENNAPARTIALMETALAREA 1.421 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.83501 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.928 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.2761 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 19.8155 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 96.3807 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.411396 LAYER VIA34 ;
  END RST
  PIN RX_IN 
    ANTENNAPARTIALMETALAREA 0.216 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.03896 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 3.008 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.6609 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 14.372 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 69.3217 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4485 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 82.7501 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 400.46 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.02119 LAYER VIA56 ;
  END RX_IN
  PIN TX_OUT 
    ANTENNAPARTIALMETALAREA 2.005 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.64405 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 5.306 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.7143 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 12.887 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 62.1789 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNADIFFAREA 0.537 LAYER METAL6 ; 
    ANTENNAPARTIALMETALAREA 6.454 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 31.2361 LAYER METAL6 ;
  END TX_OUT
END SYS_TOP

END LIBRARY
